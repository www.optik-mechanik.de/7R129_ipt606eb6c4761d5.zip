# Autodesk Inventor part: 7R129
## iProperties
Created: 2007-06
Part Number: 7R129
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
